Commit message: diff_drive

File: urdf/robot.urdf (robot description, URDF)
Before this commit: robot simple_robot, 4 links, 3 joints
Links:
- link base_link: mass 5.0 -> 10.0
